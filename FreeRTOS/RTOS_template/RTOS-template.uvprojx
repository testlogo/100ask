# Keil uVision project RTOS-template.uvprojx, settings and files
target RTOS-template (ARM-ADS)
  output: RTOS-template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .eide\deps;lib\cmsis;src;hal\STM32F10x_StdPeriph_Driver;hal\STM32F10x_StdPeriph_Driver\src;hal\STM32F10x_StdPeriph_Driver\inc;FreeRTOS\src;FreeRTOS\port\RVDS\ARM_CM3;FreeRTOS\port\MemMang;FreeRTOS\include
  asm define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  library: MicroLIB
  memory RVCT1: RAM 0x08000000 size 0x80000
  memory RVCT6: RAM 0x20000000 size 0x10000
  group SRC
    src/: main.c startup_stm32f10x_hd.s stm32f10x_it.c
  group HAL/STM32F10X_STDPERIPH_DRIVER
    hal/STM32F10x_StdPeriph_Driver/: system_stm32f10x.c
  group HAL/STM32F10X_STDPERIPH_DRIVER/SRC
    hal/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FREERTOS/SRC
    FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOS/PORT/RVDS/ARM_CM3
    FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FREERTOS/PORT/MEMMANG
    FreeRTOS/port/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group HAL
    .eide/deps/usart/: bsp_usart.c
    .eide/deps/led/: bsp_led.c
    .eide/deps/key/: bsp_key.c
    .eide/deps/exti/: bsp_exti.c
